# Keil uVision project 1602test.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 1602test_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: 1602test_2.c
