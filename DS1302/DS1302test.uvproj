# Keil uVision project DS1302test.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: DS1302test
  c flags: Optimize=8 SizeSpeed=1
